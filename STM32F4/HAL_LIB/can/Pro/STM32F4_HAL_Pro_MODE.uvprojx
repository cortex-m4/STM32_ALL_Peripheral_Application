# Keil uVision project STM32F4_HAL_Pro_MODE.uvprojx, settings and files
target STM32F4_HAL_Pro_MODE (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4_HAL_Pro_MODE
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F407XX,USE_HAL_DRIVER
  c include: ..\APP;..\STM32HAL_Lib\Core;..\STM32HAL_Lib\Inc;..\STM32HAL_Lib\Inc\Legacy;..\USER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../STM32HAL_Lib/Core/: startup_stm32f410rx.s system_stm32f4xx.c
  group STM32F4HAL_Lib
    ../STM32HAL_Lib/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c
    ../../../../../STM32_ALL_PRO_MODE/STM32F4/HAL/STM32HAL_Lib/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_usart.c stm32f4xx_hal_uart.c
  group USER
    ../USER/: main.c stm32f4xx_it.c MY_Systick.c
  group APP
    ../APP/: MY_GPIO.c MY_CAN.c MY_UART.c
  group Doc
    ../Doc/: readme.txt

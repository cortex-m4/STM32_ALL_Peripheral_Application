# Keil uVision project flash_lib.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F410RBTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: flash_lib
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\USER;.\LIB;.\CORE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group LIB
    ./LIB/: my_stm32f4xx_flash.c stm32f4xx_flash.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c
  group USER
    ./USER/: main.c my_uart.c
  group DOC
    ./doc/: readme.txt
software components: CMSIS:CORE 5.1.1, Device:Startup 2.6.2

# Keil uVision project STM32F4_STD_PRO_MODE.uvprojx, settings and files
target STM32F4_STD_PRO_MODE (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F410RBTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4_STD_PRO_MODE +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F410xx
  c include: ..\APP;..\STM32Lib\Core;..\STM32Lib\inc;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CORE
    ../STM32Lib/Core/: system_stm32f4xx.c startup_stm32f410xx.s
  group STM32F4Lib
    ../STM32Lib/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_dma.c stm32f4xx_usart.c
    ../../../../../STM32_ALL_PRO_MODE/STM32F4/STD/STM32Lib/src/: stm32f4xx_tim.c
  group USER
    ../USER/: main.c stm32f4xx_it.c MY_Systick.c
  group APP
    ../APP/: MY_GPIO.c MY_Uart.c MY_DMA.c TIM_InputCapture.c
  group Doc
    ../Doc/: readme.txt
